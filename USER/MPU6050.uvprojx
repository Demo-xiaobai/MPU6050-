# Keil uVision project MPU6050.uvprojx, settings and files
target MPU6050 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/MPU6050/: mpuiic.c mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/: ANO.c ANO.h OLED.c OLED.h OLED_Font.h uart1.c uart1.h PWM.c PWM.h Motor_Encoder.h Motor_Encoder.c PID.c PID.h Motor.c Motor.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group README
    ../: README.TXT
